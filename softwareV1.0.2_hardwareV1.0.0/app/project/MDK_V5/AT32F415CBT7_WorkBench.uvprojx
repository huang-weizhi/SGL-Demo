# Keil uVision project AT32F415CBT7_WorkBench.uvprojx, settings and files
target AT32F415CBT7_WorkBench (6220000::V6.22::ARMCLANG)
  device: -AT32F415CBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.7
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32F415CBT7_WorkBench +hex
  AfterMake: .\keil5_disp_size_bar.exe
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: AT32F415CBT7, USE_STDPERIPH_DRIVER
  c misc: --include ../app/ui_glue.h
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\app;..\ui;..\common;..\interface;..\ui_base;..\ui_show_page;..\..\middlewares\sgl\source\include;..\..\middlewares\sgl\source;..\sgl\source;..\sgl\source\include;../../middlewares/freertos/source/include;../../middlewares/freertos/source/portable/memmang;../../middlewares/freertos/source/portable/GCC/ARM_CM3;..\sgl\source\components\bench;..\sgl_ui;..\sgl_ui\screens
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f415_wk_config.c at32f415_int.c wk_system.c freertos_app.c include_port.c wk_adc.c wk_crc.c wk_debug.c wk_spi.c wk_usart.c wk_gpio.c wk_dma.c wk_tmr.c wk_wdt.c
  group firmware
    ../../libraries/drivers/src/: at32f415_adc.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_flash.c at32f415_gpio.c at32f415_misc.c at32f415_pwc.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_dma.c at32f415_wdt.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ./: startup_at32f415.s
  group common
    ../common/: iap.c CZ01.c pid_operation.c
  group app
    ../app/: input_handle.c output_handle.c pc_handle.c flash_handle.c ui_handle.c
  group interface
    ../interface/: Inf_key.c Inf_uart.c Inf_w25qxxx.c Inf_beep.c Inf_lcd.c Inf_lcd_dev.c Inf_lcd_port.c inf_sgl_port.c
  group sgl
    ../sgl/source/core/: sgl_anim.c sgl_block.c sgl_core.c sgl_event.c sgl_fs.c sgl_log.c sgl_math.c sgl_snprintf.c
    ../sgl/source/draw/: sgl_draw.c sgl_draw_arc.c sgl_draw_bezier.c sgl_draw_circle.c sgl_draw_icon.c sgl_draw_line.c sgl_draw_rect.c sgl_draw_ring.c sgl_draw_text.c
    ../sgl/source/fonts/: sgl_ascii_consolas14.c sgl_ascii_consolas23.c sgl_ascii_consolas24.c sgl_ascii_consolas24_compress.c sgl_ascii_consolas32.c sgl_ascii_song23.c sgl_icon_fontawesome14.c
    ../sgl/source/mm/lwmem/: lwmem.c sgl_mm.c
    ../sgl/source/widgets/2dball/: sgl_2dball.c
    ../sgl/source/widgets/analogclock/: sgl_analogclock.c
    ../sgl/source/widgets/arc/: sgl_arc.c
    ../sgl/source/widgets/arc_label/: sgl_arc_label.c
    ../sgl/source/widgets/avi/: sgl_avi.c
    ../sgl/source/widgets/bar/: sgl_bar.c
    ../sgl/source/widgets/barcode/: sgl_barcode.c
    ../sgl/source/widgets/battery/: sgl_battery.c
    ../sgl/source/widgets/box/: sgl_box.c
    ../sgl/source/widgets/button/: sgl_button.c
    ../sgl/source/widgets/calendar/: sgl_calendar.c
    ../sgl/source/widgets/canvas/: sgl_canvas.c
    ../sgl/source/widgets/charge/: sgl_charge.c
    ../sgl/source/widgets/chart/barchart/: sgl_barchart.c
    ../sgl/source/widgets/chart/linechart/: sgl_linechart.c
    ../sgl/source/widgets/chart/piechart/: sgl_piechart.c
    ../sgl/source/widgets/checkbox/: sgl_checkbox.c
    ../sgl/source/widgets/circle/: sgl_circle.c
    ../sgl/source/widgets/coverflow/: sgl_coverflow.c
    ../sgl/source/widgets/curve/: sgl_curve.c
    ../sgl/source/widgets/digitalclock/: sgl_digitalclock.c
    ../sgl/source/widgets/dropdown/: sgl_dropdown.c
    ../sgl/source/widgets/filebrowser/: sgl_filebrowser.c
    ../sgl/source/widgets/filedialog/: sgl_filedialog.c
    ../sgl/source/widgets/gauge/: sgl_gauge.c
    ../sgl/source/widgets/gif/: sgl_gif.c
    ../sgl/source/widgets/gifdec/: sgl_gifdec.c
    ../sgl/source/widgets/icon/: sgl_icon.c
    ../sgl/source/widgets/img/: sgl_img.c
    ../sgl/source/widgets/img_ext/: sgl_img_ext.c
    ../sgl/source/widgets/keyboard/: sgl_keyboard.c
    ../sgl/source/widgets/label/: sgl_label.c
    ../sgl/source/widgets/label_ext/: sgl_label_ext.c
    ../sgl/source/widgets/launcher/: sgl_launcher.c
    ../sgl/source/widgets/led/: sgl_led.c
    ../sgl/source/widgets/line/: sgl_line.c
    ../sgl/source/widgets/menu/: sgl_menu.c
    ../sgl/source/widgets/msgbox/: sgl_msgbox.c
    ../sgl/source/widgets/numberkbd/: sgl_numberkbd.c
    ../sgl/source/widgets/polygon/: sgl_polygon.c
    ../sgl/source/widgets/progress/: sgl_progress.c
    ../sgl/source/widgets/qrcode/: qrcode.c sgl_qrcode.c
    ../sgl/source/widgets/rect/: sgl_rect.c
    ../sgl/source/widgets/rect_ext/: sgl_rect_ext.c
    ../sgl/source/widgets/ring/: sgl_ring.c
    ../sgl/source/widgets/roller/: sgl_roller.c
    ../sgl/source/widgets/scope/: sgl_scope.c
    ../sgl/source/widgets/scrollview/: sgl_scrollview.c
    ../sgl/source/widgets/slider/: sgl_slider.c
    ../sgl/source/widgets/slimlabel/: sgl_slimlabel.c
    ../sgl/source/widgets/span/: sgl_span.c
    ../sgl/source/widgets/spectrum/: sgl_spectrum.c
    ../sgl/source/widgets/spinner/: sgl_spinner.c
    ../sgl/source/widgets/sprite/: sgl_sprite.c
    ../sgl/source/widgets/statusbar/: sgl_statusbar.c
    ../sgl/source/widgets/stepper/: sgl_stepper.c
    ../sgl/source/widgets/switch/: sgl_switch.c
    ../sgl/source/widgets/table/: sgl_table.c
    ../sgl/source/widgets/tabview/: sgl_tabview.c
    ../sgl/source/widgets/textbox/: sgl_textbox.c
    ../sgl/source/widgets/textedit/: sgl_textedit.c
    ../sgl/source/widgets/textline/: sgl_textline.c
    ../sgl/source/widgets/textlist/: sgl_textlist.c
    ../sgl/source/widgets/toast/: sgl_toast.c
    ../sgl/source/widgets/unzip_image/: sgl_unzip_image.c
    ../sgl/source/widgets/viewlist/: sgl_viewlist.c
    ../sgl/source/widgets/win/: sgl_win.c
    ../sgl/source/components/timer/: sgl_timer.c
  group middlewares/freertos
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group sgl_ui
    ../sgl_ui/: event.c helper.c ui.c
  group sgl_screens
    ../sgl_ui/screens/: screen0.c screen1.c
